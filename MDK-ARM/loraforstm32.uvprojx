# Keil uVision project loraforstm32.uvprojx, settings and files
target loraforstm32 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L051K8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: loraforstm32
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L051xx
  c misc: --C99
  c include: ../Inc;            ../Drivers/STM32L0xx_HAL_Driver/Inc;            ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;            ../Drivers/CMSIS/Device/ST/STM32L0xx/Include;            ../Drivers/CMSIS/Include;            ..\Drivers\HARDWARE\OLED;            ..\Drivers\HARDWARE\BSP;            ..\Drivers\HARDWARE\RF
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: gpio.c stm32l0xx_it.c main.c i2c.c usart.c adc.c stm32l0xx_hal_msp.c spi.c dma.c
  group Drivers/hardware/RF
    ../Drivers/HARDWARE/RF/: radio.c SX1276.C sx1276-Fsk.c sx1276-FskMisc.c sx1276-Hal.c sx1276-LoRa.c sx1276-LoRaMisc.c
  group Drivers/hardware/BSP
    ../Drivers/HARDWARE/BSP/: bsp.c
    ../Drivers/HARDWARE/OLED/: oled.c
  group Application/MDK-ARM
    ./: startup_stm32l051xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_i2c.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_cortex.c stm32l0xx_hal_adc.c stm32l0xx_hal_pwr.c stm32l0xx_hal_flash.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_tim.c stm32l0xx_hal.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_spi.c
software components: CMSIS:CORE 4.1.0
